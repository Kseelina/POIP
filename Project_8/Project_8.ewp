# IAR project Project_8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Registers\STM32F411; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; C:\Users\Home\Documents\GitHub\CortexLib\Common; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Registers; R:\POIP\POIP\Project_8\Hardware; R:\POIP\POIP\Project_8\Hardware\Pin; R:\POIP\POIP\Project_8\Components; R:\POIP\POIP\Project_8\Components\LED; R:\POIP\POIP\Project_8\Components\Button; R:\POIP\POIP\Project_8\Modes; R:\POIP\POIP\Project_8\Modes\AllMode; R:\POIP\POIP\Project_8\Modes\ChessMode; R:\POIP\POIP\Project_8\Modes\TreeMode
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Project_8.srec
  ILINK.IlinkOutputFile: Project_8.out
  ILINK.IlinkIcfFile: R:\POIP\POIP\Project_8\Project_8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: Garland.h main.cpp
  group Components/Button
    Components/Button/: Button.cpp IButton.h IPinReadable.h
  group Components/LED
    Components/LED/: ILED.h LED.cpp
  group Hardware/Pin
    Hardware/Pin/: Fake.h ipin.h pin.h pinconfig.h
  group Modes
    Modes/: IMode.h
  group Modes/AllMode
    Modes/AllMode/: AllMode.cpp
  group Modes/ChessMode
    Modes/ChessMode/: ChessMode.cpp
  group Modes/TreeMode
    Modes/TreeMode/: TreeMode.cpp
