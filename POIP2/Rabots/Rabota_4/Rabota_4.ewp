# IAR project Rabota_4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RC ST STM32F411RC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Registers\STM32F411; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; C:\Users\Home\Documents\GitHub\CortexLib\Common; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Registers; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Registers\CortexM4\FieldValues; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Registers\CortexM4; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\InterruptHandler; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Components; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Components\Button; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Components\LED; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Components\Observer; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Hardware; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Hardware\Pin; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Modes; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Modes\AllMode; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Modes\ChessMode; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Modes\SlideMode; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Modes\TreeMode; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Uart\Stm32Fxx\STM32F411; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Uart\Stm32Fxx; C:\Users\Home\Documents\GitHub\CortexLib\AbstractHardware\Uart; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Hardware\Sender; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Applications; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Applications\Parameters; R:\POIP\POIP\POIP2\Rabots\Rabota_4\Hardware\ADC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Rabota_4.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Garland.h main.cpp StartUp.cpp
  group Applications/Parameters
    Applications/Parameters/: CalibratedTemperature.cpp CalibratedTemperature.h IMeasureParameter.h Temperature.cpp Temperature.h
  group Components/Button
    Components/Button/: Button.cpp Button.h IButton.h IPinReadable.h
  group Components/LED
    Components/LED/: ILED.h LED.cpp LED.h
  group Components/Observer
    Components/Observer/: IButtonObserver.h IObservable.h
  group Hardware/ADC
    Hardware/ADC/: ADC.cpp ADC.h IADC.h
  group Hardware/Pin
    Hardware/Pin/: Fake.h ipin.h pin.h pinconfig.h
  group Hardware/Sender
    Hardware/Sender/: Sender.h
  group Modes
    Modes/: IMode.h
  group Modes/AllMode
    Modes/AllMode/: AllMode.cpp AllMode.h
  group Modes/ChessMode
    Modes/ChessMode/: ChessMode.cpp ChessMode.h
  group Modes/SlideMode
    Modes/SlideMode/: SlideMode.cpp SlideMode.h
  group Modes/TreeMode
    Modes/TreeMode/: TreeMode.cpp TreeMode.h
